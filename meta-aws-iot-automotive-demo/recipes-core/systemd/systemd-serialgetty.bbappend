# backporting serial-autologin-root
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"