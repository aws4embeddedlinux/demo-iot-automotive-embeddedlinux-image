# overwriting template
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"